Commit message: _

File: my_robots/my_models/jaco_description/urdf/jaco_cartesian_screw.urdf (robot description, URDF)
Before this commit: robot jaco_robot, 21 links, 20 joints
Links:
- link bolt: geometry collision cylinder length=0.11 radius=0.0042; visual cylinder length=0.11 radius=0.014
